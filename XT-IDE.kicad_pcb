# Repository Bluelavasystems/xt-ide

File README.md:

Slot 8 Support

If you want to use this card with an IBM 5160 PC/XT in Slot 8, you need a small daughterboard to make this happen.

Based on Glitch Works, LLC XT-IDE rev 4: https://github.com/glitchwrks/xt_ide

## KiCad design XT-IDE.kicad_pcb

Schematic: XT-IDE.sch, XT-IDE 8-bit ISA IDE Controller

Parts:
BUS1: BUSPC; ISA-8BIT-XT-IDE
C1, C2, C3, C4, C5, C6, C7, C8, C10, C11: C; AX_300
C9: C; AX_400
C12: 47uF; CP_RAD_250_100
D1: LED; LED-5MM
IDE1: CONN_20X2; STRAIGHT_2x20
J1, J2: CONN_3; 1x3
J3, J4: CONN_2; 1x2
J5: INTERRUPT; 5x2
P6, P7: CONN_1; 120mil_no_silkscreen
R1, R2: 470R; AX_400
R3, R4: 10K; AX_400
RP1, RP2: 10K; SIP10
SW1: I/O ADDR; DIP-16_300_OBROUND_NO_NOTCH
SW2: ROM OPT; DIP-16_300_OBROUND_NO_NOTCH
TP1, TP2, TP3: CONN_1; TH_TESTPOINT
U1, U2: 74LS573; DIP-20_300_OBROUND
U3, U11: 74LS245; DIP-20_300_OBROUND
U4, U6: 74LS04; DIP-14_300_OBROUND
U5: 74LS32; DIP-14_300_OBROUND
U7: 74LS138; DIP-16_300_OBROUND
U8, U10: 74LS688; DIP-20_300_OBROUND
U9: 28C256; DIP-28_600_OBROUND

Connections:
*CARDSEL: BUS1.8, SW1.8
*CARDSEL_SWITCHED: SW1.9, TP1.1
*CS_IDE: TP3.1, U5.1, U5.5, U7.4 (E1), U8.19 (P=R), U11.19 (CE)
*DASP: IDE1.39, R1.2, U6.13
*HI_BYTE_OUTPUT: U5.12, U7.13 (O2)
*HI_OUT_DELAYED: U2.1 (OE), U4.12
*IOR-ISA: BUS1.14, TP2.1, U4.1, U7.2 (A1), U11.1 (A->B)
*IOR_DELAYED: U3.13 (B5), U4.6
*MEMW: BUS1.11, SW2.8
/3: U2.11 (Load), U6.8
/4: U1.1 (OE), U7.10 (O5)
/5: U1.11 (Load), U6.6
/6: U3.17 (B1), U5.3
/7: U3.18 (B0), U5.6
/*CS1FX: IDE1.37, U3.2 (A0)
/*CS3FX: IDE1.38, U3.3 (A1)
/*IOR-IDE: IDE1.25, U3.7 (A5)
/*IOW-IDE: IDE1.23, U3.8 (A6)
/*IOW-ISA: BUS1.13, U3.12 (B6), U7.1 (A0)
/*MEMR: BUS1.12, U9.22 (OE)
/*RESET: IDE1.1, U3.9 (A7)
//CS_ROM: U9.20 (CS), U10.19 (P=R)
/A0-IDE: IDE1.35, U3.5 (A3)
/A0-ISA: BUS1.62, J1.3, J2.1, U9.10 (A0)
/A1-IDE: IDE1.33, U3.6 (A4)
/A1-ISA: BUS1.61, U3.14 (B4), U5.10, U9.9 (A1)
/A2-IDE: IDE1.36, U3.4 (A2)
/A2-ISA: BUS1.60, U3.16 (B2), U5.9, U9.8 (A2)
/A3: BUS1.59, J1.1, J2.3, U9.7 (A3)
/A10: BUS1.52, U9.21 (A10)
/A11: BUS1.51, U9.23 (A11)
/A12: BUS1.50, U9.2 (A12)
/D8: IDE1.4, U1.2 (D0), U2.19 (Q0)
/D9: IDE1.6, U1.3 (D1), U2.18 (Q1)
/D10: IDE1.8, U1.4 (D2), U2.17 (Q2)
/D11: IDE1.10, U1.5 (D3), U2.16 (Q3)
/D12: IDE1.12, U1.6 (D4), U2.15 (Q4)
/D13: IDE1.14, U1.7 (D5), U2.14 (Q5)
/D14: IDE1.16, U1.8 (D6), U2.13 (Q6)
/D15: IDE1.18, U1.9 (D7), U2.12 (Q7)
/DMARQ: IDE1.21
/INTRQ: IDE1.31, J5.2, J5.4, J5.6, J5.8, J5.10
/IOCS16: IDE1.32
/IORDY: IDE1.27
/IRQ3: BUS1.25, J5.3
/IRQ4: BUS1.24, J5.5
/IRQ5: BUS1.23, J5.7
/IRQ7: BUS1.21, J5.9
/PC-DB0: BUS1.40, U9.11 (D0), U11.2 (A0)
/PC-DB1: BUS1.39, U9.12 (D1), U11.3 (A1)
/PC-DB2: BUS1.38, U9.13 (D2), U11.4 (A2)
/PC-DB3: BUS1.37, U9.15 (D3), U11.5 (A3)
/PC-DB4: BUS1.36, U9.16 (D4), U11.6 (A4)
/PC-DB5: BUS1.35, U9.17 (D5), U11.7 (A5)
/PC-DB6: BUS1.34, U9.18 (D6), U11.8 (A6)
/PC-DB7: BUS1.33, U9.19 (D7), U11.9 (A7)
/PDIAG: IDE1.34
/ROM_WE: R3.2, SW2.9, U9.27 (WE)
/VCC_CF: IDE1.20, J4.2
A4: BUS1.58, U8.13 (P5), U9.6 (A4)
A5: BUS1.57, U8.15 (P6), U9.5 (A5)
A6: BUS1.56, U8.17 (P7), U9.4 (A6)
A7: BUS1.55, U8.6 (P2), U9.3 (A7)
A8: BUS1.54, U8.4 (P1), U9.25 (A8)
A9: BUS1.53, U8.2 (P0), U9.24 (A9)
A13: BUS1.49, SW2.6, U9.26 (A13)
A14: BUS1.48, SW2.5, U9.1 (A14)
A15: BUS1.47, U10.5 (R1)
A16: BUS1.46, U10.3 (R0)
A17: BUS1.45, U10.14 (R5)
A18: BUS1.44, U10.16 (R6)
A19: BUS1.43, U10.18 (R7)
AEN: BUS1.42, SW2.7, U8.1 (G)
D0: IDE1.17, U1.19 (Q0), U2.2 (D0), U11.18 (B0)
D1: IDE1.15, U1.18 (Q1), U2.3 (D1), U11.17 (B1)
D2: IDE1.13, U1.17 (Q2), U2.4 (D2), U11.16 (B2)
D3: IDE1.11, U1.16 (Q3), U2.5 (D3), U11.15 (B3)
D4: IDE1.9, U1.15 (Q4), U2.6 (D4), U11.14 (B4)
D5: IDE1.7, U1.14 (Q5), U2.7 (D5), U11.13 (B5)
D6: IDE1.5, U1.13 (Q6), U2.8 (D6), U11.12 (B6)
D7: IDE1.3, RP2.2, U1.12 (Q7), U2.9 (D7), U11.11 (B7)
GND: BUS1.1, BUS1.31, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, IDE1.2, IDE1.19, IDE1.22, IDE1.24, IDE1.26, IDE1.28, IDE1.30, IDE1.40, J3.1, P6.1, P7.1, RP1.1, RP2.1, U1.10 (GND), U2.10 (GND), U3.1 (A->B), U3.10 (GND), U3.19 (CE), U4.7 (GND), U5.7 (GND), U5.13, U6.7 (GND), U7.8 (GND), U8.8 (P3), U8.9 (R3), U8.10 (GND), U8.11 (P4), U8.12 (R4), U9.14 (GND), U10.10 (GND), U10.11 (P4), U10.12 (R4), U10.13 (P5), U11.10 (GND)
IRQ2: BUS1.4, J5.1
unnamed: D1.1 (K), R1.1
unnamed: J1.2, U5.4, U6.1, U7.3 (A2)
unnamed: J2.2, U3.15 (B3), U7.5 (E2)
unnamed: J3.2, R2.1
unnamed: R2.2, U6.12
unnamed: R4.2, SW2.10, U10.1 (G)
unnamed: RP1.3, SW1.16, U8.3 (R0)
unnamed: RP1.4, SW1.15, U8.5 (R1)
unnamed: RP1.5, SW1.14, U8.7 (R2)
unnamed: RP1.6, SW1.13, U8.18 (R7)
unnamed: RP1.7, SW1.12, U8.16 (R6)
unnamed: RP1.8, SW1.11, U8.14 (R5)
unnamed: RP2.3, SW2.16, U10.2 (P0)
unnamed: RP2.4, SW2.15, U10.4 (P1)
unnamed: RP2.5, SW2.14, U10.6 (P2)
unnamed: RP2.6, SW2.13, U10.8 (P3)
unnamed: RP2.7, SW2.12, U10.7 (R2)
unnamed: RP2.8, SW2.11, U10.9 (R3)
unnamed: U3.11 (B7), U6.4
unnamed: U4.2, U4.3
unnamed: U4.9, U5.11
unnamed: U4.5, U4.10
unnamed: U4.4, U4.11
unnamed: U4.8, U4.13
unnamed: U5.2, U6.2
unnamed: U5.8, U6.11
unnamed: U6.5, U7.14 (O1)
unnamed: U6.9, U7.9 (O6)
unnamed: U6.10, U7.6 (E3)
RESDRV: BUS1.2, U6.3
VCC: BUS1.3, BUS1.29, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, D1.2 (A), IDE1.29, J4.1, R3.1, R4.1, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW2.1, SW2.2, SW2.3, SW2.4, U1.20 (VCC), U2.20 (VCC), U3.20 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.16 (VCC), U8.20 (VCC), U9.28 (VCC), U10.15 (P6), U10.17 (P7), U10.20 (VCC), U11.20 (VCC)

Notes on the sheet:
IDE/CF POWER SUPPLY OPTION JUMPER
IDE ACTIVITY LEDS OBSERVE POLARITY -- PIN 1 CATHODE
IDE INTERRUPT SELECTION JUMPERS
IDE IO PORT ADDRESS
NOTE: FOR COMPATIBILITY MODE SET PINS 1-2 (DEFAULT) J2 AND J3 FOR HI-SPEED ("CHUCK MOD") MODE SET PINS 2-3 (OPTION) J2 AND J3
NOTE: Only compatible with Atmel 28C64B revision 8K EEPROMs
NOTE: ROM 0xC0000 - 0xDFFFF only
Switch Settings 1-4 ROM Address (ON == 1) 5 A14 Enable (ON == enabled) 6 A13 (ON == enabled) 7 ROM Enable (ON == enabled) 8 Write Enable (ON == enabled)
ROM Address Notes: For full 32K device (28C256) set S1 3,4,5,6 OFF For 8K device (28C64B) set S1 5,6 ON S1 3,4 become address switches
Optional (but probably desired) Boot ROM
Mounting Holes
Bypass and Decoupling Capacitors
RP2 always required, or 10K resistor between pins 1-2
NOTE: Interrupts not used on current BIOSes
Card Select (XT Slot 8 Support)
ALL CAPS MARKED C ARE 0.01 - 0.1 uF BYPASS
For use with Slot 8 Support mod
I/O Delay Chains
*IOR_DELAYED causes IDE devices to output past the latch strobe time.
*HI_OUT_DELAYED causes the high data byte to be output past *IOR-ISA time.
Slot 8 Suppor Test Points

Board: 2 copper layers, 114.3 x 106.7 mm, 44 parts (0 on the bottom side), 110 nets.

## Commit log

2020-08-28 Update README.md
    Adding attribution and link to our original repository
